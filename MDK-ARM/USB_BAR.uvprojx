# Keil uVision project USB_BAR.uvprojx, settings and files
target USB_BAR (ARM-ADS)
  device: STM32F205RE STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USB_BAR +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc;  ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F2xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_dma_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_rtc.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_pwr.c stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pcd_ex.c stm32f2xx_ll_usb.c stm32f2xx_hal_rng.c stm32f2xx_hal_rcc.c stm32f2xx_hal_gpio.c stm32f2xx_hal_crc.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Application/User
    ../Src/: usbd_conf.c usb_device.c main.c usbd_desc.c usbd_custom_hid_if.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
software components: CMSIS:CORE 4.1.0
